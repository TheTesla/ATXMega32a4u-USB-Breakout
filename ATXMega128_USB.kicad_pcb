# Repository TheTesla/ATXMega32a4u-USB-Breakout

File README.md:

ATXMega32a4u-USB-Breakout
=========================

Breakoutboard for ATXMega32a4u to ATXMega128a4u with micro-USB

Creator: http://entroserv.de

Support: support@entroserv.de (german and english)

# Quickstart

power up: connect 3.3 V to pin3 and GND to pin2 -> yellow led is illuminated

programming: connect atmel jtagice3 to the pdi header on top side of the board

## KiCad design ATXMega128_USB.kicad_pcb

Parts:
C1, C3, C9, C12, C13: 10u; SM0805; Manufacturer Part Number CC0805ZKY5V6BB106; Digi-Key Part Number 311-1355-1-ND
C2, C4, C5, C6, C7, C8: 100n; SM0603_Capa; Manufacturer Part Number CL10F104ZA8NNNC; Digi-Key Part Number 1276-1011-1-ND
C10, C11: 18p; SM0805; Manufacturer Part Number CL21C180JBANNNC; Digi-Key Part Number 1276-1107-1-ND
D1: LED; LED-0805; Manufacturer Part Number LG R971-KN-1; Digi-Key Part Number 475-1410-1-ND
D2: LED; LED-0805; Manufacturer Part Number LS R976-NR-1; Digi-Key Part Number 475-1278-1-ND
D3: LED; LED-0805; Manufacturer Part Number LY R976-PS-36; Digi-Key Part Number 475-2560-1-ND
D4: BAS70BRW; SOT-363; Digi-Key Part Number BAS70BRW-TPCT-ND
D5: LED; LED-0805; Manufacturer Part Number LTST-C170TBKT; Digi-Key Part Number 160-1579-1-ND
D6: 6V2; SOD323; Manufacturer Part Number MM3Z6V2ST1G; Digi-Key Part Number MM3Z6V2ST1GOSCT-ND
IC1: ATXMEGA128A4U; TQFP44; Manufacturer Part Number ATXMEGA128A4U-AU; Digi-Key Part Number ATXMEGA128A4U-AU-ND
L1, L2: 100n; SM0805; Manufacturer Part Number AIML-0805-R10K-T; Digi-Key Part Number 535-11645-1-ND
P1, P3: CONN_20; PIN_ARRAY_20X1
P2: CONN_3X2; pin_array_3x2
P4: MICROUSB; MICRO-B_USB; Manufacturer Part Number 10118192-0001LF; Digi-Key Part Number 609-4613-2-ND
R1: 10k; SM0805; Digi-Key Part Number RMCF0805JG10K0-ND
R2, R3, R4: 1k; SM0805; Manufacturer Part Number RMCF0805JT1K00; Digi-Key Part Number RMCF0805JT1K00CT-ND
R5: 1k5; SM0805; Manufacturer Part Number RMCF0805JT1K50; Digi-Key Part Number RMCF0805JT1K50CT-ND
X1: 4 MHz; HC-49V; Manufacturer Part Number ATS040B; Digi-Key Part Number CTX896-ND

Connections:
/AVCC: C5.2, C12.1, IC1.39 (AVCC), L2.2
/PA0: C1.1, C2.1, IC1.40 (PA0(ADC0/AC0/AREF)), P1.1
/PA1: IC1.41 (PA1(ADC1/AC1)), P1.2
/PA2: IC1.42 (PA2(ADC2/AC2)), P1.3
/PA3: IC1.43 (PA3(ADC3/AC3)), P1.4
/PA4: IC1.44 (PA4(ADC4/AC4)), P1.5
/PA5: IC1.1 (PA5(ADC5/AC5)), P1.6
/PA6: IC1.2 (PA6(ADC6/AC6/AC1_OUT)), P1.7
/PA7: IC1.3 (PA7(ADC7/AC7/AC0_OUT)), P1.8
/PB0: C3.1, C4.1, IC1.4 (PB0(ADC8/AREF)), P1.9
/PB1: IC1.5 (PB1(ADC9)), P1.10
/PB2: IC1.6 (PB2(ADC10/DAC0)), P1.11
/PB3: IC1.7 (PB3(ADC11/DAC1)), P1.12
/PC0: IC1.10 ((OC0A/~OC0ALS~/SDA)PC0), P1.13
/PC1: IC1.11 ((OC0B/OC0AHS/SCL/XCK0)PC1), P1.14
/PC2: IC1.12 ((OC0C/~OC0BLS~/RXD0)PC2), P1.15
/PC3: IC1.13 ((OC0D/OC0BHS/TXD0)PC3), P1.16
/PC4: IC1.14 ((~OC0CLS~/OC1A/~SS~)PC4), P1.17
/PC5: IC1.15 ((OC0CHS/OC1B/XCK1/MOSI)PC5), P1.18
/PC6: IC1.16 ((~OC0DLS~/RXD1/MISO/clk_RTC)PC6), P1.19, R2.2
/PC7: IC1.17 ((OC0DHS/TXD1/SCK/CLKOUT/EVOUT/clk_PER)P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), P1.20, R3.2
/PD0: IC1.20 ((OC0A)PD0), P3.4
/PD1: IC1.21 ((OC0B/XCK0)PD1), P3.5
/PD2: IC1.22 ((OC0C/RXD0)PD2), P3.6
/PD3: IC1.23 ((OC0D/TXD0)PD3), P3.7
/PD4: IC1.24 ((OC1A/~SS~)PD4), P3.8
/PD5: IC1.25 ((OC1B/XCK1/MOSI)PD5), P3.9
/PD6: D4.6 (AK), IC1.26 ((RXD1/MISO/D-)PD6), P3.10, P4.2 (D-)
/PD7: D4.3 (AK), IC1.27 ((TXD1/SCK/CLKOUT/EVOUT/D+/clk_PER)PD7), P3.11, P4.3 (D+)
/PDI: IC1.34 (PDI_DATA), P2.1, P3.16
/PE0: IC1.28 ((OC0A/SDA)PE0), P3.12
/PE1: IC1.29 ((OC0B/SCL/XCK0)PE1), P3.13
/PE2: IC1.32 ((OC0C/RXD0)PE2), P3.14
/PE3: IC1.33 ((OC0D/TXD0)PE3), P3.15
/PR0: C11.1, IC1.36 ((XTAL2/TOSC2)PR0), P3.18, X1.2
/PR1: C10.1, IC1.37 ((XTAL1/TOSC1)PR1), P3.19, X1.1
/RESET: IC1.35 (~RESET~/PDI_CLK), P2.5, P3.17, R1.2
/VCC: C6.1, C7.1, C8.1, C9.1, C13.1, IC1.9 (VCC), IC1.19 (VCC), IC1.31 (VCC), L1.1, L2.1, P2.2, R1.1, R4.2
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, D1.2 (K), D2.2 (K), D3.2 (K), D4.1 (anode), D4.2 (Anode), D5.2 (K), D6.1 (A), IC1.8 (GND), IC1.18 (GND), IC1.30 (GND), IC1.38 (GND), P2.6, P3.2, P3.20, P4.5 (GND)
unnamed: D2.1 (A), R3.1
unnamed: D1.1 (A), R2.1
unnamed: D5.1 (A), R5.1
unnamed: D3.1 (A), R4.1
unnamed: D4.4 (cathode), D4.5 (cathode), D6.2 (K), P3.1, P4.1 (VCC), R5.2

Notes on the sheet:
ATXMega USB Breakout Board

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
Board: 2 copper layers, 50.8 x 25.4 mm, 32 parts (0 on the bottom side), 45 nets.

## KiCad design ATXMega128_USB_TEST_Board/ATXMega128_USB_TEST_Board.kicad_pcb

Parts:
C1, C2: 330n
C3, C4, C5: 100n
C6: 100u
C7, C8: 10u
CON1: BARREL_JACK
D1, D2, D3, D4, D6, D7, D10, D11, D12, D13, D14: LED
D5, D15: 1N4148
D8: 5V6
D9: 9V6
D16, D17: 4V7
IC1: ATXMEGA128A4U_BOARD; ATXMega128a4u_Breakout
J1: USBJACK
P1: CONN_3X2
Q1, Q3, Q5: BC807-40; SOT-23
Q2, Q4: BC817-40; SOT-23
R1, R2, R6, R10, R12, R13, R25, R26, R27, R28, R31, R32, R34, R35, R36, R37, R38: 1k
R3, R4, R5, R7, R8, R9, R14, R15, R16, R17, R18, R20, R22, R23, R29, R30: 10k
R11, R33: 4k7
R19, R21: 100k
R24: 470
U1: MC78L12ACH; SOT-89
U2: NCP1117ST33T3G

Connections:
+3.3V: C3.2, C8.1, D10.1 (A), D13.1 (A), IC1.3, P1.2, R1.1, R10.2, R12.2, U2.2 (VO)
+12V: C2.2, C5.2, C7.1, Q1.2 (E), R26.1, U1.3 (OUT), U2.3 (VI)
GND: C1.1, C2.1, C3.1, C5.1, C6.2, C7.2, C8.2, CON1.2, CON1.3, D1.2 (K), D2.2 (K), D3.2 (K), D8.1 (A), D11.2 (K), D14.2 (K), D16.1 (A), D17.1 (A), IC1.2, P1.6, R27.1, R35.1, U1.2 (GND), U2.1 (GND)
unnamed: IC1.5, R22.1
unnamed: IC1.39, R17.2
unnamed: IC1.4, R17.1
unnamed: IC1.34, R16.2
unnamed: IC1.40, R16.1
unnamed: IC1.33, R15.2
unnamed: IC1.35, R15.1
unnamed: IC1.6, R23.2
unnamed: IC1.8, R23.1
unnamed: IC1.7, R18.2
unnamed: D3.1 (A), R6.2
unnamed: IC1.31, R6.1, R9.1
unnamed: D1.1 (A), R1.2
unnamed: IC1.25, R8.2
unnamed: IC1.24, R3.1
unnamed: IC1.22, R3.2
unnamed: IC1.23, R2.1, R7.1
unnamed: IC1.21, R7.2
unnamed: J1.3 (DATA+), R29.1
unnamed: J1.2 (DATA-), R30.1
unnamed: D12.2 (K), J1.4 (GND)
unnamed: D9.1 (A), IC1.38, R22.2
unnamed: IC1.9, R18.1
unnamed: IC1.13, R21.1
unnamed: IC1.15, R19.1
unnamed: IC1.19, R21.2
unnamed: IC1.18, R19.2
unnamed: IC1.36, R30.2
unnamed: IC1.37, R29.2
unnamed: D2.1 (A), R2.2
unnamed: IC1.32, R5.1
unnamed: IC1.30, R5.2
unnamed: IC1.29, R9.2
unnamed: IC1.28, R4.1
unnamed: IC1.26, R4.2
unnamed: IC1.27, R8.1
unnamed: CON1.1, D15.1 (A)
unnamed: C1.2, C6.1, D15.2 (K), U1.1 (IN)
unnamed: IC1.12, R14.2
unnamed: D4.2 (K), IC1.20
unnamed: D8.2 (K), R13.2, R20.2
unnamed: IC1.14, R14.1
unnamed: IC1.17, P1.5
unnamed: D7.2 (K), R13.1
unnamed: J1.1 (VBUS), R33.1
unnamed: IC1.16, P1.1
unnamed: D5.1 (A), R10.1
unnamed: Q1.1 (B), R25.1
unnamed: D11.1 (A), R32.2
unnamed: Q3.3 (C), R32.1
unnamed: C4.1, R34.2
unnamed: D10.2 (K), R31.1
unnamed: Q2.3 (C), R31.2
unnamed: D14.1 (A), R38.2
unnamed: Q5.3 (C), R38.1
unnamed: D17.2 (K), Q5.1 (B), R36.2
unnamed: D13.2 (K), R37.1
unnamed: D12.1 (A), R33.2
unnamed: Q4.3 (C), R37.2
unnamed: Q4.1 (B), R35.2
unnamed: D16.2 (K), Q3.1 (B), R28.2
unnamed: Q2.1 (B), R27.2
unnamed: D4.1 (A), R12.1
unnamed: Q1.3 (C), R24.1, R28.1, R36.1
unnamed: D9.2 (K), R25.2, R26.2
unnamed: C4.2, IC1.11, Q4.2 (E), Q5.2 (E)
unnamed: D5.2 (K), D6.1 (A), R11.1
unnamed: D6.2 (K), D7.1 (A), IC1.1, R11.2, R20.1, R24.2
unnamed: IC1.10, Q2.2 (E), Q3.2 (E), R34.1

Board: 2 copper layers, 69.8 x 52.7 mm, 78 parts (0 on the bottom side), 72 nets.

Other parts of the board:
drill-M3, drill-M3#2, drill-M3#3, drill-M3#4: VAL**; drill-M3

## Commit log

2013-04-05 Grundversion USB-Buchse: mouser micro-USB USB-ESD-Schutz: Standard BAS70 einzelne Dioden ATXMega: TQFP-44
2013-04-06 USB-ESD protection: BAS70BRW Schematic bearbeitet
2013-04-06 Board mit BAS70BRW (schlechtes Layout)
2013-04-06 Layout mit BAS70BRW besser, USB-LED verschoben
2013-04-06 Update der Bestellnummern, Bauteilwerte
2013-04-07 Z-Diode (USB ESD)
2013-04-07 Update BOM, Rename-Script
2013-04-07 Kupfer-Abstand auf 0,2 mm erhöht
2013-04-07 LED-Gehäuse geändert (0805 -> LED-0805) Rename-Script Board-Outline umbenannt (GBR->GKO)
2013-04-15 Seeed OPL SKU ergänzt; csv mit neuem eigenem xsl-Plugin
2013-04-19 removed space from one Digi-Key Part Number
2013-05-14 updated parts - BOM
2013-05-19 components changed: cheaper leds, minimum quantity 1, no obsolete parts
2013-08-17 footprint BAS70 SOT-363 changed (larger pads), footprint micro-USB changed
2013-08-29 PIN names added
2013-08-29 Xmega128a4u text added
2013-08-31 new branch: atxmega128a4u, version with text on PCB
2013-08-31 no message
2013-09-01 lib-cache-file added
2013-09-01 lib-cache-file added (was in gitignore)
2013-09-01 board and schematic updated to atxmega128a4u
2013-09-01 annotation
2013-09-08 Test-Board-Design started
2013-09-09 Test-Board schematic nearly ready
2013-09-10 ATXMega_Breaout-Footprint designed, Testboard PCB started
2013-09-13 Testboard PCB designed
2013-09-13 Power Supply Diode added, Board Edge Cuts added
2013-09-15 Testboard complete
2013-10-11 Testboard updated, Testsoftware ready
2013-10-12 testboard images and DFU USB bootloader added
2013-10-12 software legal information (bootloader) formated better
2013-10-12 BOM csv with tabulators instead of commas, xlsx-file
2014-01-26 better package for D4, D4 shifted down
2014-06-08 Produktbeschreibung (german) + Declaration of Conformity
2014-06-11 added additional information
2014-07-25 Changed notes.: it is nota an electrical appliance, it is an electronic device (ElektroG)
2014-08-14 silkscreen changes: LEDs "RX" and "TX", text "entroserv.de"
2014-08-21 some changes on silk screen/text
2014-09-09 little changes in Hinweise
2017-03-19 placed copyright on back
